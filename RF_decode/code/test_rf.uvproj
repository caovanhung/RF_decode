# Keil uVision project test_rf.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: test_rf +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\N76E003_BSP_Keil_C51_V1.0.5;..\N76E003_BSP_Keil_C51_V1.0.5\Include
  group Source
    ./: test_rf.c
  group Startup
    ../N76E003_BSP_Keil_C51_V1.0.5/Startup/: STARTUP.A51
